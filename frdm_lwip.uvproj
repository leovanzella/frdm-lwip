# Keil uVision project frdm_lwip.uvproj, settings and files
target frdm_lwip (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: frdm_lwip
  c flags: Optim=1
  c include: .\include;.\lwip\include;.\lwip;.\lwip\include\ipv4;.\BSP\include;.\lwIP\arch;.\lwIP\include\ipv4\lwip;.\lwIP\include\lwip;.\lwIP\include\netif;.\httpserver_raw;.\ports\enc28j60\include;.\ports\enc28j60\netif
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x5000
  memory RVCT10: RAM 0x20004000 size 0x3000
  group Source
    ./: ticker.c EMAC.c main.c startup_MKL25Z4.s system_MK25Z4.c fs.c spi.c enc28j60.c
  group lwIP
    ./lwIP/core/: stats.c mem.c memp.c pbuf.c netif.c tcp.c tcp_out.c tcp_in.c raw.c udp.c dhcp.c sys.c dns.c timers.c
    ./lwIP/core/ipv4/: ip_addr.c ip.c ip_frag.c icmp.c inet.c inet_chksum.c
    ./lwIP/arch/: clock.c
    ./lwIP/netif/: ethernetif.c etharp.c
  group ports
    ./ports/enc28j60/netif/: enc28j60_lowlevel.c
